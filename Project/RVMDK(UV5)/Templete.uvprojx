# Keil uVision project Templete.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Templete +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\USER;..\..\USER\bsp_i2c_ee;..\..\USER\bsp_i2c_gpio;..\..\USER\bsp_usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../../Libraries/FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group USER
    ../../USER/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../USER/bsp_i2c_ee/: bsp_i2c_ee.c
    ../../USER/bsp_i2c_gpio/: bsp_i2c_gpio.c
    ../../USER/bsp_usart/: bsp_usart.c
  group DOC
    ../../DOC/: readme.txt
